# Keil uVision project FinalProject.uvproj, settings and files
target FinalProject (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: FinalProject
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: ST7735.c Speaker.c Button.c PLL.c Timer.c MotionDetect.c startup.s Serial.c Microphone.c DAC.c Keypad.c Servo.c main.c Alarm.c SysTick.c
